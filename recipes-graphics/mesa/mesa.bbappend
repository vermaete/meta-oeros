# Copyright (c) 2026 Wind River Systems, Inc.

PACKAGECONFIG:remove = "opencl"
